# Repository larsskj/larsskj-009

File README.md:

A Breakout PCB for testing LEDs
===============================

### larsskj-009

This board is a simple breakout board to connect LEDs (or other consumers) for testing before soldering them permanently to my larsskj-003 boards.

For more information, visit the [project homepage](https://larsskj.org/projects/larsskj-009).

The files provided are project files for [KiCad 5](http://kicad-pcb.org/).

## KiCad design larsskj-009.kicad_pcb

Board: 2 copper layers, 38.1 x 45.7 mm, 3 parts (0 on the bottom side), 16 nets.

Parts:
J1: IDC Connector; IDC-Header_2x08_P2.54mm_Vertical
J2, J3: Conn_01x08; TerminalBlock_Phoenix_MPT-0,5-8-2.54_1x08_P2.54mm_Horizontal

Connections:
unnamed: J1.1, J2.1
unnamed: J1.2, J2.2
unnamed: J1.3, J2.3
unnamed: J1.4, J2.4
unnamed: J1.5, J2.5
unnamed: J1.6, J2.6
unnamed: J1.7, J2.7
unnamed: J1.8, J2.8
unnamed: J1.9, J3.1
unnamed: J1.10, J3.2
unnamed: J1.11, J3.3
unnamed: J1.12, J3.4
unnamed: J1.13, J3.5
unnamed: J1.14, J3.6
unnamed: J1.15, J3.7
unnamed: J1.16, J3.8

## Commit log

2021-08-26 Files added.
